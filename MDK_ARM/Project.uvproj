# Keil uVision project Project.uvproj, settings and files
target HT32F1755_2755_DVB (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HT32F1755 Holtek
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x00000000-0x0001FBFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HT32F1755_2755_DVB
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F1755_2755_DVB, LCD_2_8
  c include: ..\;..\library\HT32F175x_275x_Driver\inc;..\library\CMSIS\Include;..\library\Device\Holtek\HT32F175x_275x\Include;..\utilities;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group User
    ../src/: main.c ht32f175x_275x_it.c
  group RVMDK
    ../library/Device/Holtek/HT32F175x_275x/Source/ARM/: startup_ht32f175x_275x.s
  group Library
    ../library/HT32F175x_275x_Driver/src/: ht32f175x_275x_adc.c ht32f175x_275x_bftm.c ht32f175x_275x_ckcu.c ht32f175x_275x_cmp_op.c ht32f175x_275x_exti.c ht32f175x_275x_flash.c ht32f175x_275x_gpio.c ht32f175x_275x_gptm.c ht32f175x_275x_i2c.c ht32f175x_275x_lib.c ht32f175x_275x_mctm.c ht32f175x_275x_misc.c ht32f175x_275x_pdma.c ht32f175x_275x_pwrcu.c ht32f175x_275x_rstcu.c ht32f175x_275x_rtc.c ht32f175x_275x_sci.c ht32f175x_275x_serial.c ht32f175x_275x_spi.c ht32f175x_275x_usart.c ht32f175x_275x_usbd.c ht32f175x_275x_wdt.c ht32f275x_csif.c
  group Retarget
    ../library/HT32F175x_275x_Driver/src/: holtek_retarget.c
  group CMSIS
    ../library/Device/Holtek/HT32F175x_275x/Source/: system_ht32f175x_275x.c
  group Utilities
    ../utilities/HT32F1755_2755_DVB/: ht32f1755_2755_dvb.c i2c_eeprom.c spi_flash.c spi_lcd.c
