# IAR project Project.ewp, settings and files
configuration HT32F1755_2755_DVB (ARM, debug)
  General.OGChipSelectEditMenu: HT32F1755 Holtek HT32F1755
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HT32_DRIVER; USE_HT32F1755_2755_DVB
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\library\HT32F175x_275x_Driver\inc; ..\..\..\..\library\CMSIS\Include; ..\..\..\..\library\Device\Holtek\HT32F175x_275x\Include; ..\..\..\..\utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: HT32F175x_275x_DVB.out
  ILINK.IlinkIcfFile: ht32f175x_275x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../: system_ht32f175x_275x.c
  group EWARM
    ./: startup_ht32f175x_275x.s
  group Library
    ../../../../library/HT32F175x_275x_Driver/src/: ht32f175x_275x_adc.c ht32f175x_275x_bftm.c ht32f175x_275x_ckcu.c ht32f175x_275x_cmp_op.c ht32f175x_275x_exti.c ht32f175x_275x_flash.c ht32f175x_275x_gpio.c ht32f175x_275x_gptm.c ht32f175x_275x_i2c.c ht32f175x_275x_lib.c ht32f175x_275x_mctm.c ht32f175x_275x_misc.c ht32f175x_275x_pdma.c ht32f175x_275x_pwrcu.c ht32f175x_275x_rstcu.c ht32f175x_275x_rtc.c ht32f175x_275x_sci.c ht32f175x_275x_serial.c ht32f175x_275x_spi.c ht32f175x_275x_usart.c ht32f175x_275x_usbd.c ht32f175x_275x_wdt.c ht32f275x_csif.c
  group Retarget
    ../../../../library/HT32F175x_275x_Driver/src/: holtek_retarget.c
  group User
    ../: ht32f175x_275x_it.c main.c
  group Utilities
    ../../../../utilities/HT32F1755_2755_DVB/: ht32f1755_2755_dvb.c i2c_eeprom.c spi_flash.c spi_lcd.c
